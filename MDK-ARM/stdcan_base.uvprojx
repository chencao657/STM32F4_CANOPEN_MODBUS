# Keil uVision project stdcan_base.uvprojx, settings and files
target stdcan_base (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: stdcan_base +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;       ../Drivers/STM32F4xx_HAL_Driver/Inc;       ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;       ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;       ../Drivers/CMSIS/Include;       ..\CANopenNode_STM32;       ..\CANopenNode;       ..\Drivers\BSP\JAWD;       ..\CANopenNode\301
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group CANopenNode
    ../CANopenNode/301/: CO_Emergency.c CO_fifo.c CO_HBconsumer.c CO_NMT_Heartbeat.c CO_ODinterface.c CO_PDO.c CO_SDOclient.c CO_SDOserver.c CO_SYNC.c CO_TIME.c crc16-ccitt.c
    ../CANopenNode/303/: CO_LEDs.c
    ../CANopenNode/304/: CO_GFC.c CO_SRDO.c
    ../CANopenNode/305/: CO_LSSmaster.c CO_LSSslave.c
    ../CANopenNode/309/: CO_gateway_ascii.c
    ../CANopenNode/extra/: CO_trace.c
    ../CANopenNode/storage/: CO_storage.c CO_storageEeprom.c
    ../CANopenNode/: CANopen.c
  group CANopenNode_STM32
    ../CANopenNode_STM32/: CO_app_STM32.c CO_driver_STM32.c CO_storageBlank.c OD.c
  group JAWD
    ../Drivers/BSP/JAWD/: JAWD_SPEED.c JAWD_SPEED.h canopen_operate.c canopen_operate.h key.c modbus_tim.c modbus_tim.h modbus_usart.c modbus_usart.h modbus_slave.c modbus_slave.h user_lib.c user_lib.h modbus_msg.c modbus_msg.h
software components: CMSIS:CORE 5.1.1, Compiler:Event Recorder 1.4.0
